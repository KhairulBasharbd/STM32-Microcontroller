# Keil uVision project I2C with DS3231 and LCD.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: I2C with DS3231 and LCD
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: main.c main.h i2c-lcd.c i2c-lcd.h stm32f1xx_hal_msp.c stm32f1xx_it.c syscalls.c sysmem.c system_stm32f1xx.c
software components: CMSIS:CORE 6.0.0, CMSIS Driver:I2C 2.2, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
